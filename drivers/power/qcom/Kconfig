## drivers/power/qcom/Kconfig
```kconfig
config ASUS_POWER_DEBUG
        bool "ASUS POWER DEBUG"
        default n
        help
          This enables asus power debug feature
```
